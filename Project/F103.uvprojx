# Keil uVision project F103.uvprojx, settings and files
target KEY_LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Drive\Source;..\Drive\Include;..\STM32\STM32F10x_StdPeriph_Driver\inc;..\MY;..\STM32\CMSIS\CM3\CoreSupport;..\STM32\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MY
    ../MY/: main.c stm32f10x_it.c
  group Driver
    ../Drive/Source/: delay.c key.c led.c usart.c encoder.c PID_cal_tim6.c Timer.c MotorDrive.c FuzzyPID.c Movement.c Rece.c IMU.c Laser.c SendCmd.c
  group STM32
    ../STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
    ../STM32/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../STM32/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
